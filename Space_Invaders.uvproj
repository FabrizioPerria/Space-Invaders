# Keil uVision project Space_Invaders.uvproj, settings and files
target Space_Invaders (ARM-ADS)
  device: TM4C123GE6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Space_Invaders
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: rvmdk PART_LM4F120H5QR
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: PLL.c ADC.c DAC.c Systick.c Button.c main.c input.c Timer2A.c Sound.c Display.c Video.c Enemies.c Player.c Weapon.c Bunker.c
  group asm
    ./: startup_TM4C123.s
  group hdr
    ./: Weapon.h Button.h ADC.h DAC.h shared_registers.h Systick.h PLL.h debug.h input.h Timer2A.h Sound.h Display.h Video.h Enemies.h Player.h Bunker.h
  group sounds
    ./: explosion_sound.h shoot_sound.h
  group images
    ./: enemy10PT.h enemy15Pt.h enemy20Pt.h enemy40Pt.h enemy50Pt.h playerShip.h laser.h exploded.h
  group fonts
    ./: font.h
